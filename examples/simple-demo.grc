options:
  parameters:
    author: luigi
    generate_options: qt_gui
    id: simple
    output_language: python
    title: CyberEther Demo
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 60e6
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: cyber_ether_sink_0
  id: cyber_ether_sink
  parameters:
    ui_enable: 'True'
  states: {}
- name: soapy_limesdr_source_0
  id: soapy_limesdr_source
  parameters:
    bandwidth: samp_rate
    center_freq: 1847e6
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_plutosdr_source_0
  id: soapy_plutosdr_source
  parameters:
    agc: 'True'
    bandwidth: 10e6
    center_freq: 96.9e6
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}

connections:
- [blocks_throttle_0, '0', cyber_ether_sink_0, '0']
- [soapy_limesdr_source_0, '0', blocks_throttle_0, '0']
- [soapy_plutosdr_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
